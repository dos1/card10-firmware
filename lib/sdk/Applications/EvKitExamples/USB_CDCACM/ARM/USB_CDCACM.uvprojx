# Keil uVision project USB_CDCACM.uvprojx, settings and files
target Flash Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32665:Cortex-M4 Maxim
  pack: Maxim.MAX32665.0.2.0-5l
  cpu: IRAM(0x20000000,0x00080000) IROM(0x10000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(96000000) ELITTLE
  output: USB_CDCACM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group Source
    ../: main.c
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.2, BSP:EvKit V1 0.2.0-5l, Device:GPIO 0.2.0-5l, Device:Startup 0.2.0-5l, Device:UART 0.2.0-5l, Device:XiP Flash 0.2.0-5l, USB:Core 0.2.0-5l, USB:Device Class 0.2.0-5l, Device:UART 0.2.0-5l, Device:Timers 0.2.0-5l
